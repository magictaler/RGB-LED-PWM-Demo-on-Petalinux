IMAGE_INSTALL_append = " bootscript"
